# Keil uVision project stm32f10x_Car.uvprojx, settings and files
target CAR (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_Car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\FWlib\inc;..\Sys_Init\inc;..\User_Prog\inc;..\BSP\inc;..\APP\inc;..\LIB\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USE_Prog
    ../User_Prog/src/: device_timer.c main.c scheduler.c Task_Data_input.c Task_Data_output.c init.c Task_Data_Remap.c time.c Common_Data_Area.c
  group Sys_int
    ../Sys_Init/src/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Std_Driver
    ../FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c
  group BSP
    ../BSP/src/: bsp_led.c bsp_lora.c bsp_scom.c bsp_scom_it.c bsp_motor.c bsp_pwm.c bsp_exti.c bsp_ultrasonic.c bsp_ultrasonic_it.c bsp_led_it.c bsp_iwdg.c bsp_oled.c bsp_robotarm.c
  group APP
    ../APP/src/: algorithm_PID.c map_SCOMandSBUS.c map_XDATA.c
  group LIB
    ../LIB/inc/: lib_oledfont.h
